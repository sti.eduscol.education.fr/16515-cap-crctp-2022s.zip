Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-12-01T09:55:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180328_1600(x64) - Exporter 19.0.1.1 - Interface utilisateur alternative 19.0.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 01 09:55:03 2020 * Host: LGB8019 * Database: C:\Users\ADAMA~1.KAN\AppData\Local\Temp\{4A3A9646-DD39-40C7-B502-886C82D88940}\ifc * Database version: 5507 * Database creation date: Tue Dec 01 09:55:03 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 01 09:55:03 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 01 09:55:03 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm

# IfcBuildingElementProxy: Chambre de tirage K3C, Famille K3C.rfa - CAP:Chambre de tirage K3C:142716
In: Niveau 1
Pset_ManufacturerTypeInformation - Manufacturer: Stradal
Pset_BuildingElementProxyCommon - Reference: Chambre de tirage K3C
